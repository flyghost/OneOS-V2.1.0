# Keil uVision project project.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OC_DYNAMIC_ALLOCATION, STM32H743xx, OC_SERVER, OS_TASK_SWITCH_NOTIFY, MBEDTLS_MPI_MAX_SIZE=73, MBEDTLS_SSL_MAX_CONTENT_LEN=2048, MBEDTLS_ECP_FIXED_POINT_OPTIM=0, ONEOS_2_0, OC_SECURITY, OC_IPV4, OC_DEBUG, USE_GUI, MBEDTLS_HAVE_ASM, USE_HAL_DRIVER, MBEDTLS_ECP_NIST_OPTIM, NO_MAIN, __OC_RANDOM, MBEDTLS_ECP_MAX_BITS=256
  c misc: --locale=english
  c include: .;application;application\ui;..\..\thirdparty\ocf\iotivity-lite-2.2.0\port;..\..\arch\arm\armv7m\include;board;board\CubeMX_Config\Inc;board\ports;..\..\components\cli\include;..\..\common\include;..\..\components\dlog\include;..\..\drivers;..\..\drivers\bus;..\..\drivers\console;..\..\drivers\dma;..\..\drivers\fal;..\..\drivers\i2c;..\..\drivers\misc;..\..\drivers\pin;..\..\drivers\rtc;..\..\drivers\sdio;..\..\drivers\serial;..\..\drivers\timer;..\..\drivers\watchdog;..\..\drivers\graphic;..\..\thirdparty\gui\lvgl;..\..\thirdparty\gui\lvgl\lvgl;..\..\thirdparty\gui\lvgl\lvgl\src;..\..\drivers\hal\st\devices;..\..\drivers\hal\st\drivers;..\..\drivers\hal\st\drivers\config;..\..\drivers\hal\st\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;..\..\drivers\hal\st\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;..\..\drivers\hal\st\STM32H7xx_HAL\CMSIS\Include;..\..\thirdparty\ocf\port\oneos\src;..\..\thirdparty\ocf\iotivity-lite-2.2.0\include;..\..\thirdparty\ocf\iotivity-lite-2.2.0;..\..\thirdparty\ocf\iotivity-lite-2.2.0\deps\mbedtls\include;..\..\kernel\include;..\..\libc\include;..\..\libc\include\extension;..\..\libc\include\armlibc;..\..\components\net\molink\api\include;..\..\components\net\molink\core\include;..\..\components\net\molink\module\esp8266\include;..\..\components\net\molink\parser\include;..\..\components\net\molink\tools\include;..\..\components\position;..\..\components\position\ble_pos\onepos_engine;..\..\components\position\ble_pos\onepos_engine\ope_base_calculate;..\..\components\position\ble_pos\onepos_engine\ope_base_funtion;..\..\components\position\ble_pos\onepos_engine\ope_base_funtion\ope_position_lib;..\..\components\position\ble_pos\onepos_engine\ope_base_funtion\ope_position_lib\ope_general_lib;..\..\components\position\gnss_pos;..\..\components\position\gnss_pos\prot;..\..\components\position\gnss_pos\rcvr;..\..\components\position\net_pos;..\..\osal\posix\include\pthreads;..\..\osal\posix\include\time;..\..\components\shell\include;..\..\components\net\socket\include;..\..\components\net\socket\include\sys_socket;..\..\components\diagnose\stack_trace
  asm define: OS_TASK_SWITCH_NOTIFY
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314
  group application
    application/: main.c rtc_test.c
    ../../demos/driver/: serial_test.c fal_test.c
    application/ui/: ui.c ocf_font_44.c waterheater_ui.c
  group arch
    ../../arch/arm/armv7m/rvds/: arch_exception_rvds.S arch_task_switch_rvds.S
    ../../arch/arm/armv7m/: arch_cache.c arch_task.c arch_exception.c arch_interrupt.c arch_misc.c arch_atomic.c
  group bsp
    board/: board.c
    board/CubeMX_Config/Src/: bsp.c stm32h7xx_it_bsp.c stm32h7xx_hal_msp.c system_stm32h7xx.c
    board/startup/: startup_stm32h743xx_arm.s
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group dlog
    ../../components/dlog/source/: dlog.c
    ../../components/dlog/source/backend/: console_backend.c
  group drivers
    ../../drivers/: driver.c device.c
    ../../drivers/block/: block_device.c
    ../../drivers/bus/: bus.c
    ../../drivers/console/: console.c
    ../../drivers/dma/: dma_ram.c soft_dma.c
    ../../drivers/fal/: fal.c fal_part.c fal_block.c
    ../../drivers/i2c/: i2c.c soft_i2c_bus.c soft_i2c_bus_config.c
    ../../drivers/misc/: push_button.c
    ../../drivers/pin/: pin.c pcf8574.c
    ../../drivers/rtc/: rtc.c
    ../../drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    ../../drivers/serial/: serial.c
    ../../drivers/timer/: timer.c clocksource.c clockevent.c hrtimer.c clocksource_cortexm.c
    ../../drivers/watchdog/: watchdog.c
  group graphic
    ../../drivers/graphic/: graphic.c
  group gui/lvgl
    ../../thirdparty/gui/lvgl/lvgl/: lvgl.c
    ../../thirdparty/gui/lvgl/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../../thirdparty/gui/lvgl/lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../thirdparty/gui/lvgl/lvgl/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../../thirdparty/gui/lvgl/lvgl/src/lv_gpu/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_vglite.c lv_gpu_stm32_dma2d.c
    ../../thirdparty/gui/lvgl/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../thirdparty/gui/lvgl/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../thirdparty/gui/lvgl/lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ../../thirdparty/gui/lvgl/lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
  group hal/devices
    ../../drivers/hal/st/devices/: stm32_devices.c
  group hal/drivers
    ../../drivers/hal/st/drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_i2c.c drv_sdram.c drv_rtc.c drv_iwdg.c drv_lcd.c drv_common.c
    ../../drivers/hal/st/drivers/flash/: drv_flash_h7.c
  group hal/lowlevel
    ../../drivers/hal/st/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cec.c stm32h7xx_hal_cortex.c stm32h7xx_hal_comp.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_sram.c stm32h7xx_hal_gpio.c stm32h7xx_hal_exti.c stm32h7xx_hal_hsem.c stm32h7xx_hal_uart.c stm32h7xx_hal_usart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_qspi.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_hcd.c stm32h7xx_ll_usb.c stm32h7xx_hal_tim.c stm32h7xx_ll_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_hrtim.c stm32h7xx_ll_hrtim.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_dma2d.c
  group iotivity
    ../../thirdparty/ocf/iotivity-lite-2.2.0/apps/: waterheater_simpleserver.c
    ../../thirdparty/ocf/port/oneos/src/: ocf_cmd.c ipadapter.c random.c clock.c abort.c storage.c oc_mem.c oc_mem_log.c
    ../../thirdparty/ocf/iotivity-lite-2.2.0/deps/tinycbor/src/: cborencoder_close_container_checked.c cborencoder.c cborparser.c
    ../../thirdparty/ocf/iotivity-lite-2.2.0/messaging/coap/: engine.c coap.c transactions.c separate.c observe.c
    ../../thirdparty/ocf/iotivity-lite-2.2.0/util/: oc_memb.c oc_etimer.c oc_list.c oc_process.c oc_timer.c oc_mmem.c
    ../../thirdparty/ocf/iotivity-lite-2.2.0/api/: oc_discovery.c oc_main.c oc_buffer.c oc_server_api.c oc_client_api.c oc_helpers.c oc_ri.c oc_rep.c oc_uuid.c oc_endpoint.c oc_core_res.c oc_network_events.c oc_blockwise.c oc_base64.c oc_enums.c oc_introspection.c oc_collection.c oc_session_events.c oc_clock.c
    ../../thirdparty/ocf/iotivity-lite-2.2.0/deps/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c threading.c timing.c version.c version_features.c xtea.c pkcs11.c x509.c x509_crt.c net_sockets.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c memory_buffer_alloc.c platform_util.c rsa_internal.c debug.c
    ../../thirdparty/ocf/iotivity-lite-2.2.0/security/: oc_acl.c oc_cred.c oc_doxm.c oc_pstat.c oc_store.c oc_svr.c oc_sdi.c oc_audit.c oc_tls.c oc_ael.c oc_sp.c
    ../../thirdparty/ocf/iotivity-lite-2.2.0/api/c-timestamp/: timestamp_format.c timestamp_parse.c timestamp_valid.c
  group kernel
    ../../kernel/source/: os_block.c os_clock.c os_event.c os_idle.c os_kernel_lock.c os_kernel_log.c os_mb.c os_mem_firstfit.c os_mem_pool.c os_memory.c os_mq.c os_mutex.c os_sched.c os_sem.c os_spinlock.c os_startup.c os_task.c os_timer.c os_util.c os_version.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: access.c chdir.c close.c dirent.c fcntl.c fstat.c fsync.c getcwd.c ioctl.c libc.c lseek.c mem_std.c mkdir.c open.c read.c rename.c rmdir.c stat.c statfs.c stdio.c strdup.c strnlen.c stubs.c time.c unlink.c write.c
    ../../libc/source/common/: gmtime_r.c
  group molink
    ../../components/net/molink/api/source/: mo_common.c mo_factory.c mo_general.c mo_ping.c mo_ifconfig.c mo_netconn.c mo_socket.c mo_wifi.c
    ../../components/net/molink/core/source/: mo_object.c mo_lib.c mo_ipaddr.c mo_time.c
    ../../components/net/molink/module/esp8266/source/: esp8266.c esp8266_general.c esp8266_wifi.c esp8266_ping.c esp8266_ifconfig.c esp8266_netconn.c
    ../../components/net/molink/parser/source/: at_parser.c at_resp.c at_printf.c
    ../../components/net/molink/tools/source/: tool.c
  group pthreads
    ../../osal/posix/source/pthreads/: mqueue.c pthread.c pthread_attr.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c pthread_spin.c pthread_tls.c sched.c semaphore.c
    ../../osal/posix/source/time/: clock_time.c posix_sleep.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
  group socket
    ../../components/net/socket/source/: socket.c
