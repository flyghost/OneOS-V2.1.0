# Keil uVision project project.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CM32M101A-L64 CMIOT
  pack: China Mobile IOT Company Limited(CMIOT).CM32M101A_DFP.0.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: oneos
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: SOC_SERIES_CM32M1_XXX, USE_HAL_DRIVER
  c include: .;application;..\..\arch\arm\armv7m\include;board;board\ports;..\..\drivers\hal\cmiot\CM32M10x_HAL\std_periph_driver\inc;..\..\drivers\hal\cmiot\CM32M10x_HAL\algo_lib\inc;..\..\drivers\hal\cmiot\CM32M10x_HAL\CMSIS\core;..\..\drivers\hal\cmiot\CM32M10x_HAL\CMSIS\device;..\..\common\include;..\..\components\dlog\include;..\..\drivers;..\..\drivers\bus;..\..\drivers\console;..\..\drivers\dma;..\..\drivers\fal;..\..\drivers\mtd;..\..\drivers\pin;..\..\drivers\serial;..\..\drivers\hal\cmiot\devices;..\..\drivers\hal\cmiot\drivers;..\..\drivers\hal\cmiot\CM32M10x_HAL\std_periph_driver\inc;..\..\drivers\hal\cmiot\CM32M10x_HAL\algo_lib\inc;..\..\drivers\hal\cmiot\CM32M10x_HAL\CMSIS\core;..\..\drivers\hal\cmiot\CM32M10x_HAL\CMSIS\device;..\..\kernel\include;..\..\libc\include;..\..\libc\include\extension;..\..\libc\include\armlibc;..\..\components\position;..\..\components\position\gnss_pos;..\..\components\position\gnss_pos\prot;..\..\components\position\gnss_pos\rcvr;..\..\components\position\net_pos;..\..\components\diagnose\resource_moniter;..\..\components\shell\include;..\..\components\diagnose\stack_trace
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*Handler
  group application
    application/: main.c
  group arch
    ../../arch/arm/armv7m/rvds/: arch_exception_rvds.S arch_task_switch_rvds.S
    ../../arch/arm/armv7m/: arch_task.c arch_exception.c arch_interrupt.c arch_misc.c arch_atomic.c
  group bsp
    board/: board.c
    board/startup/: startup_cm32m101a_arm.s
    ../../drivers/hal/cmiot/CM32M10x_HAL/CMSIS/device/: system_cm32m101a.c
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group dlog
    ../../components/dlog/source/: dlog.c
    ../../components/dlog/source/backend/: console_backend.c
  group drivers
    ../../drivers/: driver.c device.c
    ../../drivers/block/: block_device.c
    ../../drivers/bus/: bus.c
    ../../drivers/console/: console.c
    ../../drivers/dma/: soft_dma.c
    ../../drivers/fal/: fal.c fal_part.c fal_mtd.c fal_block.c
    ../../drivers/mtd/: mtd.c
    ../../drivers/pin/: pin.c
    ../../drivers/serial/: serial_simple.c
  group hal/devices
    ../../drivers/hal/cmiot/devices/: cm32_devices.c
  group hal/drivers
    ../../drivers/hal/cmiot/drivers/: drv_common.c drv_gpio.c drv_usart.c
    ../../drivers/hal/cmiot/drivers/flash/: drv_flash.c
  group hal/lowlevel
    ../../drivers/hal/cmiot/CM32M10x_HAL/std_periph_driver/src/: misc.c cm32m101a_gpio.c cm32m101a_rcc.c cm32m101a_usart.c cm32m101a_lpuart.c cm32m101a_flash.c cm32m101a_exti.c cm32m101a_dma.c
  group kernel
    ../../kernel/source/: os_block.c os_clock.c os_event.c os_idle.c os_kernel_lock.c os_kernel_log.c os_mb.c os_mem_firstfit.c os_mem_pool.c os_memory.c os_mutex.c os_sched.c os_sem.c os_spinlock.c os_startup.c os_task.c os_timer.c os_util.c os_version.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: access.c chdir.c close.c dirent.c fcntl.c fstat.c fsync.c getcwd.c ioctl.c libc.c lseek.c mem_std.c mkdir.c open.c read.c rename.c rmdir.c stat.c statfs.c stdio.c strdup.c strnlen.c stubs.c time.c unlink.c write.c
    ../../libc/source/common/: gmtime_r.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
