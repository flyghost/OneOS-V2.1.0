# Keil uVision project template.uvprojx, settings and files
target oneos (ARM-ADS)
  device: FM33G04X FMSH
  pack: Keil.FM33G0XX_DFP.0.3.03G
  cpu: IRAM(0x20000000,0x6000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: oneos
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314,L6330
