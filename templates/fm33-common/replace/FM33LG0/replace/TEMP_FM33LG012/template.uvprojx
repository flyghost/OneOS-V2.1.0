# Keil uVision project template.uvprojx, settings and files
target oneos (ARM-ADS)
  device: FM33LG01X FMSH
  pack: Keil.FM33LG0XX_DFP.2.0.2
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: oneos
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314,L6330
