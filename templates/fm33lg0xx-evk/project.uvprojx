# Keil uVision project project.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: FM33LG04X FMSH
  pack: Keil.FM33LG0XX_DFP.2.0.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: oneos
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: OS_TASK_SWITCH_NOTIFY, FM33LG0XX, USE_HAL_DRIVER
  c include: .;application;..\..\arch\arm\armv6m\include;board;.;board\ports;board\peripheral;..\..\components\cli\include;..\..\common\include;..\..\components\dlog\include;..\..\drivers;..\..\drivers\bus;..\..\drivers\console;..\..\drivers\dma;..\..\drivers\fal;..\..\drivers\i2c;..\..\drivers\misc;..\..\drivers\mtd;..\..\drivers\pin;..\..\drivers\rtc;..\..\drivers\serial;..\..\drivers\timer;..\..\drivers\watchdog;..\..\drivers\hal\fm\devices;..\..\drivers\hal\fm\drivers\lg0;..\..\drivers\hal\fm\FM33LG0xx_HAL\FM33LG0xx_FL_Driver\Inc;..\..\drivers\hal\fm\FM33LG0xx_HAL\CMSIS\Device\FM\FM33xx\Include;..\..\kernel\include;..\..\libc\include;..\..\libc\include\extension;..\..\libc\include\armlibc;..\..\components\position;..\..\components\position\ble_pos\onepos_engine;..\..\components\position\ble_pos\onepos_engine\ope_base_calculate;..\..\components\position\ble_pos\onepos_engine\ope_base_funtion;..\..\components\position\ble_pos\onepos_engine\ope_base_funtion\ope_position_lib;..\..\components\position\ble_pos\onepos_engine\ope_base_funtion\ope_position_lib\ope_general_lib;..\..\components\position\gnss_pos;..\..\components\position\gnss_pos\prot;..\..\components\position\gnss_pos\rcvr;..\..\components\position\net_pos;..\..\components\shell\include;..\..\components\diagnose\stack_trace
  asm define: OS_TASK_SWITCH_NOTIFY
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314,L6330
  group application
    application/: main.c
  group arch
    ../../arch/arm/armv6m/rvds/: arch_exception_rvds.S arch_task_switch_rvds.S
    ../../arch/arm/armv6m/: arch_task.c arch_exception.c arch_interrupt.c arch_misc.c arch_atomic.c
  group bsp
    board/: board.c
    board/startup/: startup_fm33lg0xx_arm.s
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group dlog
    ../../components/dlog/source/: dlog.c
    ../../components/dlog/source/backend/: console_backend.c
  group drivers
    ../../drivers/: driver.c device.c
    ../../drivers/block/: block_device.c
    ../../drivers/bus/: bus.c
    ../../drivers/console/: console.c
    ../../drivers/dma/: soft_dma.c
    ../../drivers/fal/: fal.c fal_part.c fal_mtd.c fal_block.c
    ../../drivers/i2c/: i2c.c
    ../../drivers/misc/: push_button.c adc.c
    ../../drivers/mtd/: mtd.c
    ../../drivers/pin/: pin.c
    ../../drivers/rtc/: rtc.c
    ../../drivers/serial/: serial.c
    ../../drivers/timer/: timer.c clocksource.c clockevent.c clocksource_cortexm.c
    ../../drivers/watchdog/: watchdog.c
  group hal/devices
    ../../drivers/hal/fm/devices/: fm33_devices.c
  group hal/drivers
    ../../drivers/hal/fm/drivers/lg0/: drv_common.c drv_interrupt.c drv_gpio.c drv_uart.c drv_hwtimer.c drv_rtc.c drv_adc.c drv_iwdg.c drv_i2c.c
    ../../drivers/hal/fm/drivers/lg0/flash/: drv_flash.c
  group hal/lowlevel
    ../../drivers/hal/fm/FM33LG0xx_HAL/CMSIS/Device/FM/FM33xx/Source/: system_fm33lg0xx.c
    ../../drivers/hal/fm/FM33LG0xx_HAL/FM33LG0xx_FL_Driver/Src/: fm33lg0xx_fl_gpio.c fm33lg0xx_fl_cmu.c fm33lg0xx_fl_dma.c fm33lg0xx_fl_uart.c fm33lg0xx_fl_flash.c fm33lg0xx_fl_atim.c fm33lg0xx_fl_bstim16.c fm33lg0xx_fl_bstim32.c fm33lg0xx_fl_rtca.c fm33lg0xx_fl_rtcb.c fm33lg0xx_fl_adc.c fm33lg0xx_fl_iwdt.c fm33lg0xx_fl_i2c.c
  group kernel
    ../../kernel/source/: os_block.c os_clock.c os_event.c os_idle.c os_kernel_lock.c os_kernel_log.c os_mb.c os_mem_firstfit.c os_mem_pool.c os_memory.c os_mq.c os_mutex.c os_sched.c os_sem.c os_spinlock.c os_startup.c os_task.c os_timer.c os_util.c os_version.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: access.c chdir.c close.c dirent.c fcntl.c fstat.c fsync.c getcwd.c ioctl.c libc.c lseek.c mem_std.c mkdir.c open.c read.c rename.c rmdir.c stat.c statfs.c stdio.c strdup.c strnlen.c stubs.c time.c unlink.c write.c
    ../../libc/source/common/: gmtime_r.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
