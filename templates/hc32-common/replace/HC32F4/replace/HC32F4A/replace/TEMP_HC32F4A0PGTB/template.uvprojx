# Keil uVision project template.uvprojx, settings and files
target oneos (ARM-ADS)
  device: HC32F4A0PGTB HDSC
  pack: HDSC.HC32F4A0.1.0.4
  cpu: IRAM(0x1FFE0000,0x80000) IROM(0x00000000,0x100000) IROM2(0x03000000,0x1800) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: oneos
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --diag_suppress=186,66
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*Handler --diag_suppress L6314,L6330
