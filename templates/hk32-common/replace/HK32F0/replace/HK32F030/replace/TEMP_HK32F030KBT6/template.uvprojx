# Keil uVision project template.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HK32F030C6Tx HK_MicroChip
  pack: HKMicroChip.HK32F0xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,HK32F030x6
  c include: ..\..\HK32F0xx_StdPeriph_Driver\CMSIS\HK32F0xx\Include;..\..\HK32F0xx_StdPeriph_Driver\inc;.\USER\inc;..\..\HK32F0xx_StdPeriph_Driver\CMSIS\Core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314,L6330
