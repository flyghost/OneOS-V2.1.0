# Keil uVision project project.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HK32F103VE HK_MicroChip
  pack: HKMicroChip.HK32F1xx_DFP.1.0.6
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HK32F103VEXX, USE_HAL_DRIVER
  c include: .;Application;..\..\arch\arm\armv7m\include;..\..\components\atest\include;board;board\ports;..\..\common\include;..\..\components\dlog\include;..\..\drivers;..\..\drivers\bus;..\..\drivers\console;..\..\drivers\dma;..\..\drivers\fal;..\..\drivers\misc;..\..\drivers\mtd;..\..\drivers\pin;..\..\drivers\serial;..\..\drivers\sn;..\..\drivers\timer;..\..\components\fs\include;..\..\drivers\hal\hk32\devices\f103;..\..\drivers\hal\hk32\drivers\f103;..\..\drivers\hal\hk32\HK32F103\HK32F103X_lib\inc;..\..\drivers\hal\hk32\HK32F103\CMSIS\HK32F1xx\Include;..\..\drivers\hal\hk32\HK32F103\CMSIS\CM3\Core;..\..\kernel\include;..\..\libc\include;..\..\libc\include\extension;..\..\libc\include\armlibc;..\..\components\diagnose\resource_moniter;..\..\components\shell\include;..\..\components\diagnose\stack_trace
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314,L6330
  group application
    Application/: main.c
  group arch
    ../../arch/arm/armv7m/rvds/: arch_exception_rvds.S arch_task_switch_rvds.S
    ../../arch/arm/armv7m/: arch_task.c arch_exception.c arch_interrupt.c arch_misc.c arch_atomic.c
  group atest
    ../../components/atest/source/: atest.c
  group bsp
    board/: board.c hk32f10x_it.c system_hk32f10x.c
    board/startup/: startup_hk32f103xE_arm.s
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group dlog
    ../../components/dlog/source/: dlog.c
    ../../components/dlog/source/backend/: console_backend.c
  group drivers
    ../../drivers/: driver.c device.c
    ../../drivers/block/: block_device.c
    ../../drivers/bus/: bus.c
    ../../drivers/console/: console.c
    ../../drivers/dma/: dma.c
    ../../drivers/fal/: fal.c fal_part.c fal_mtd.c fal_block.c
    ../../drivers/misc/: push_button.c
    ../../drivers/mtd/: mtd.c
    ../../drivers/pin/: pin.c
    ../../drivers/serial/: serial.c
    ../../drivers/sn/: sn_cfg.c
    ../../drivers/timer/: timer.c clocksource.c clockevent.c hrtimer.c clocksource_cortexm.c
  group filesystem
    ../../components/fs/source/: fs_cmd.c vfs.c vfs_fd.c vfs_fs.c vfs_misc.c vfs_posix.c
  group hal/devices
    ../../drivers/hal/hk32/devices/f103/: hk32_devices.c
  group hal/drivers
    ../../drivers/hal/hk32/drivers/f103/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_common.c
    ../../drivers/hal/hk32/drivers/f103/flash/: drv_flash_f1.c
  group hal/lowlevel
    ../../drivers/hal/hk32/HK32F103/HK32F103X_lib/src/: hk32f10x_adc.c hk32f10x_bkp.c hk32f10x_can.c hk32f10x_crc.c hk32f10x_dac.c hk32f10x_dbgmcu.c hk32f10x_dma.c hk32f10x_exti.c hk32f10x_flash.c hk32f10x_fsmc.c hk32f10x_gpio.c hk32f10x_i2c.c hk32f10x_iwdg.c hk32f10x_pwr.c hk32f10x_rcc.c hk32f10x_rtc.c hk32f10x_sdio.c hk32f10x_spi.c hk32f10x_tim.c hk32f10x_usart.c hk32f10x_wwdg.c misc.c
  group kernel
    ../../kernel/source/: os_block.c os_clock.c os_event.c os_idle.c os_kernel_lock.c os_kernel_log.c os_mb.c os_mem_firstfit.c os_mem_pool.c os_memory.c os_mq.c os_mutex.c os_sched.c os_sem.c os_spinlock.c os_startup.c os_task.c os_timer.c os_util.c os_version.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: access.c chdir.c close.c dirent.c fcntl.c fstat.c fsync.c getcwd.c ioctl.c libc.c lseek.c mem_std.c mkdir.c open.c read.c rename.c rmdir.c stat.c statfs.c stdio.c strdup.c strnlen.c stubs.c time.c unlink.c write.c
    ../../libc/source/common/: gmtime_r.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
