# Keil uVision project project.uvprojx, settings and files
target oneos (6140000::V6.14::ARMCLANG)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.13.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: oneos.out
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_LPC55S69JBD100_cm33_core0, OS_TASK_SWITCH_NOTIFY
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: .;applications;..\..\arch\arm\armv8m\include;..\..\arch\arm\armv8m\no-trustzone;board;board\board\board;board\ports;..\..\components\cli\include;..\..\common\include;..\..\components\dlog\include;..\..\drivers;..\..\drivers\boot\cotex-m;..\..\drivers\bus;..\..\drivers\console;..\..\drivers\dma;..\..\drivers\fal;..\..\drivers\hwcrypto;.;..\..\drivers\misc;..\..\drivers\mtd;..\..\drivers\pin;..\..\drivers\rtc;..\..\drivers\serial;..\..\drivers\timer;..\..\drivers\watchdog;..\..\drivers\hal\nxp\lpc5500\lpc55s6x\devices;..\..\drivers\hal\nxp\lpc5500\lpc55s6x\drivers;..\..\drivers\hal\nxp\lpc5500\lpc55s6x\drivers\flash;..\..\drivers\hal\nxp\lpc5500\lpc55s6x\sdk\CMSIS\Core\Include;..\..\drivers\hal\nxp\lpc5500\lpc55s6x\sdk\devices;..\..\drivers\hal\nxp\lpc5500\lpc55s6x\sdk\devices\LPC55S69;..\..\drivers\hal\nxp\lpc5500\lpc55s6x\sdk\devices\LPC55S69\drivers;..\..\drivers\hal\nxp\lpc5500\lpc55s6x\sdk\devices\LPC55S69\cmsis_drivers;..\..\drivers\hal\nxp\lpc5500\lpc55s6x\sdk\devices\LPC55S69\mcuxpresso;..\..\kernel\include;..\..\libc\include;..\..\libc\include\extension;..\..\libc\include\armlibc;..\..\components\position;..\..\components\position\ble_pos\onepos_engine;..\..\components\position\ble_pos\onepos_engine\ope_base_calculate;..\..\components\position\ble_pos\onepos_engine\ope_base_funtion;..\..\components\position\ble_pos\onepos_engine\ope_base_funtion\ope_position_lib;..\..\components\position\ble_pos\onepos_engine\ope_base_funtion\ope_position_lib\ope_general_lib;..\..\components\position\gnss_pos;..\..\components\position\gnss_pos\prot;..\..\components\position\gnss_pos\rcvr;..\..\components\position\gnss_pos\rtk;..\..\components\position\net_pos;..\..\components\shell\include;..\..\components\diagnose\stack_trace
  asm define: OS_TASK_SWITCH_NOTIFY
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314,L6330
  group application
    applications/: main.c
  group arch
    ../../arch/arm/armv8m/: arch_atomic.c arch_interrupt.c arch_misc.c
    ../../arch/arm/armv8m/no-trustzone/gcc/: arch_exception_gcc.S arch_task_switch_gcc.S
    ../../arch/arm/armv8m/no-trustzone/: arch_exception_ntz.c arch_task.c
  group bsp
    board/: board.c
    board/board/board/: clock_config.c peripherals.c pin_mux.c
    board/startup/: startup_LPC55S69_cm33_core0_arm.S
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group dlog
    ../../components/dlog/source/: dlog.c
    ../../components/dlog/source/backend/: console_backend.c
  group drivers
    ../../drivers/: driver.c device.c
    ../../drivers/block/: block_device.c
    ../../drivers/boot/cotex-m/: vector_table.c
    ../../drivers/bus/: bus.c
    ../../drivers/console/: console.c
    ../../drivers/dma/: soft_dma.c
    ../../drivers/fal/: fal.c fal_part.c fal_mtd.c fal_block.c
    ../../drivers/hwcrypto/: hwcrypto.c hw_crc.c
    ../../drivers/misc/: push_button.c adc.c
    ../../drivers/mtd/: mtd.c
    ../../drivers/pin/: pin.c
    ../../drivers/rtc/: rtc.c
    ../../drivers/serial/: serial.c
    ../../drivers/timer/: timer.c clocksource.c clockevent.c hrtimer.c clocksource_cortexm.c
    ../../drivers/watchdog/: watchdog.c
  group hal/devices
    ../../drivers/hal/nxp/lpc5500/lpc55s6x/devices/: lpc_devices.c
  group hal/drivers
    ../../drivers/hal/nxp/lpc5500/lpc55s6x/drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_adc.c drv_rtc.c drv_crypto_crc.c drv_wwdt.c drv_common.c
    ../../drivers/hal/nxp/lpc5500/lpc55s6x/drivers/flash/: drv_flash_lpc55s6x.c
  group hal/lowlevel
    ../../drivers/hal/nxp/lpc5500/lpc55s6x/sdk/devices/LPC55S69/drivers/: fsl_anactrl.c fsl_casper.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_common_arm.c fsl_dma.c fsl_flexcomm.c fsl_gint.c fsl_gpio.c fsl_hashcrypt.c fsl_iap.c fsl_inputmux.c fsl_mrt.c fsl_ostimer.c fsl_pint.c fsl_plu.c fsl_prince.c fsl_puf.c fsl_reset.c fsl_sdif.c fsl_sysctl.c fsl_crc.c fsl_ctimer.c fsl_lpadc.c fsl_rtc.c fsl_usart.c fsl_usart_dma.c fsl_wwdt.c
    ../../drivers/hal/nxp/lpc5500/lpc55s6x/sdk/devices/LPC55S69/: system_LPC55S69_cm33_core0.c
    ../../drivers/hal/nxp/lpc5500/lpc55s6x/sdk/devices/LPC55S69/arm/: keil_lib_power_cm33_core0.lib
  group kernel
    ../../kernel/source/: os_block.c os_clock.c os_event.c os_idle.c os_kernel_lock.c os_kernel_log.c os_mb.c os_mem_firstfit.c os_mem_pool.c os_memory.c os_mq.c os_mutex.c os_sched.c os_sem.c os_spinlock.c os_startup.c os_task.c os_timer.c os_util.c os_version.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: access.c chdir.c close.c dirent.c fcntl.c fstat.c fsync.c getcwd.c ioctl.c libc.c lseek.c mem_std.c mkdir.c open.c read.c rename.c rmdir.c stat.c statfs.c stdio.c strdup.c strnlen.c stubs.c time.c unlink.c write.c
    ../../libc/source/common/: gmtime_r.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
