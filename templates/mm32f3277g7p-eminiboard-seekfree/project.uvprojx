# Keil uVision project project.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32F3277G7P MindMotion
  pack: MindMotion.MM32F327x_DFP.1.0.3
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OS_TASK_SWITCH_NOTIFY
  c include: .;application;application;..\..\arch\arm\armv7m\include;board;board\ports;board\peripherals;board\peripherals;..\..\components\cli\include;..\..\common\include;..\..\components\dlog\include;..\..\drivers;..\..\drivers\bus;..\..\drivers\console;..\..\drivers\dma;..\..\drivers\fal;..\..\drivers\misc;..\..\drivers\mtd;..\..\drivers\pin;..\..\drivers\serial;..\..\drivers\timer;..\..\drivers\hal\mm32\devices;..\..\drivers\hal\mm32\drivers;..\..\drivers\hal\mm32\drivers\flash;..\..\drivers\hal\mm32\sdk\middleware;..\..\drivers\hal\mm32\sdk\middleware\sdmmc\sd;..\..\drivers\hal\mm32\sdk\MM32F327XX_HAL;..\..\drivers\hal\mm32\sdk\MM32F327XX_HAL\MM32F327x\HAL_lib\inc;..\..\drivers\hal\mm32\sdk\MM32F327XX_HAL\MM32F327x\Include;..\..\drivers\hal\mm32\sdk\MM32F327XX_HAL\CMSIS\KEIL_CORE;..\..\kernel\include;..\..\libc\include;..\..\libc\include\extension;..\..\libc\include\armlibc;..\..\components\net\molink\api\include;..\..\components\net\molink\core\include;..\..\components\net\molink\module\m5311\include;..\..\components\net\molink\parser\include;..\..\components\position;..\..\components\position\ble_pos\onepos_engine;..\..\components\position\ble_pos\onepos_engine\ope_base_calculate;..\..\components\position\ble_pos\onepos_engine\ope_base_funtion;..\..\components\position\ble_pos\onepos_engine\ope_base_funtion\ope_position_lib;..\..\components\position\ble_pos\onepos_engine\ope_base_funtion\ope_position_lib\ope_general_lib;..\..\components\position\gnss_pos;..\..\components\position\gnss_pos\prot;..\..\components\position\gnss_pos\rcvr;..\..\components\position\net_pos;..\..\components\shell\include;..\..\components\diagnose\stack_trace
  asm define: OS_TASK_SWITCH_NOTIFY
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314,L6330
  group application
    application/: main.c sensors_demo.c
  group arch
    ../../arch/arm/armv7m/rvds/: arch_exception_rvds.S arch_task_switch_rvds.S
    ../../arch/arm/armv7m/: arch_task.c arch_exception.c arch_interrupt.c arch_misc.c arch_atomic.c
  group bsp
    board/: board.c
    board/startup/: startup_mm32f327x_arm.s
    board/peripherals/: peripherals.c
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group dlog
    ../../components/dlog/source/: dlog.c
    ../../components/dlog/source/backend/: console_backend.c
  group drivers
    ../../drivers/: driver.c device.c
    ../../drivers/block/: block_device.c
    ../../drivers/bus/: bus.c
    ../../drivers/console/: console.c
    ../../drivers/dma/: soft_dma.c
    ../../drivers/fal/: fal.c fal_part.c fal_mtd.c fal_block.c
    ../../drivers/misc/: push_button.c adc.c
    ../../drivers/mtd/: mtd.c
    ../../drivers/pin/: pin.c
    ../../drivers/serial/: serial.c
    ../../drivers/timer/: timer.c clocksource.c clockevent.c hrtimer.c clocksource_cortexm.c
  group hal/devices
    ../../drivers/hal/mm32/devices/: mm32_devices.c
  group hal/drivers
    ../../drivers/hal/mm32/drivers/: drv_common.c mm32_it.c mm32_it_dma.c drv_gpio.c drv_uart.c drv_adc.c drv_hwtimer.c
    ../../drivers/hal/mm32/drivers/flash/: drv_flash_common.c
  group hal/lowlevel
    ../../drivers/hal/mm32/sdk/MM32F327XX_HAL/MM32F327x/Source/: system_mm32f327x.c
    ../../drivers/hal/mm32/sdk/MM32F327XX_HAL/MM32F327x/HAL_lib/src/: HAL_adc.c HAL_bkp.c HAL_can.c HAL_crc.c HAL_dac.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_tim.c HAL_uart.c HAL_wwdg.c HAL_sdio.c
  group kernel
    ../../kernel/source/: os_block.c os_clock.c os_event.c os_idle.c os_kernel_lock.c os_kernel_log.c os_mb.c os_mem_firstfit.c os_memory.c os_mq.c os_mutex.c os_sched.c os_sem.c os_spinlock.c os_startup.c os_task.c os_timer.c os_util.c os_version.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: access.c chdir.c close.c dirent.c fcntl.c fstat.c fsync.c getcwd.c ioctl.c libc.c lseek.c mem_std.c mkdir.c open.c read.c rename.c rmdir.c stat.c statfs.c stdio.c strdup.c strnlen.c stubs.c time.c unlink.c write.c
    ../../libc/source/common/: gmtime_r.c
  group molink
    ../../components/net/molink/api/source/: mo_common.c mo_factory.c mo_general.c mo_netserv.c mo_ping.c mo_ifconfig.c mo_netconn.c mo_onenet_nb.c
    ../../components/net/molink/core/source/: mo_object.c mo_lib.c mo_ipaddr.c mo_time.c
    ../../components/net/molink/module/m5311/source/: m5311.c m5311_general.c m5311_netserv.c m5311_ping.c m5311_ifconfig.c m5311_netconn.c m5311_onenet_nb.c
    ../../components/net/molink/parser/source/: at_parser.c at_resp.c at_printf.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
