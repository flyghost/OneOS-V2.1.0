# Keil uVision project template.uvprojx, settings and files
target oneos (6140000::V6.14::ARMCLANG)
  device: LPC55S06JBD64 NXP
  pack: NXP.LPC55S06_DFP.12.0.0
  cpu: IRAM(0x10000000,0x038000) IRAM2(0x20000000,0x010000) IROM(0x03000000,0x020000) IROM2(0x13000000,0x020000) XRAM(0x30000000,0x010000) XRAM2(0x20010000,0x4000) XRAM3(0x30010000,0x4000) XROM(0x00000000,0x038000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: oneos.out
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: .;../..;../../../..;../../../../../../CMSIS/Include;..\..\drivers\hal\nxp\LPC55S69;..\..\drivers\hal\nxp\LPC55S69\cmsis_drivers;..\..\drivers\hal\nxp\LPC55S69\drivers;..\..\common\ring_blk_buff\include;..\..\common\ring_buff\include;..\..\components\atest\include;..\..\components\dlog\include;..\..\components\fal\inc;..\..\components\fs\include;..\..\components\shell\include;..\..\drivers;..\..\drivers\hal\nxp\drivers;..\..\drivers\hal\nxp\LPC55S69\template;..\..\drivers\hal\nxp\LPC55S69\utilities;..\..\drivers\hal\nxp\LPC55S69\utilities\debug_console;..\..\drivers\hal\nxp\LPC55S69\utilities\str;..\..\kernel\include;..\..\kernel\include\extend;..\..\libc\include;..\..\libc\include\armlibc;..\..\libc\include\armlibc\sys;..\..\drivers\hal\nxp\CMSIS\Include;..\..\drivers\hal\nxp\components\uart;..\..\drivers\hal\nxp\components\serial_manager;..\..\drivers\hal\nxp\components\lists;.\board\board;..\lpc55s69-nxp-evk;.\applications;..\..\components\fs\include;..\..\drivers\serial;..\..\drivers\hal\nxp\drivers;..\..\drivers\misc;..\..\common\include
  memory RVCT1: ROM 0x0 size 0x38000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x10000
  memory RVCT7: RAM 0x20010000 size 0x4000
  memory RVCT8: RAM 0x30010000 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x38000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
