# Keil uVision project template.uvprojx, settings and files
target oneos (ARM-ADS)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F479xx
  c include: .;appplication;board;board\CubeMX_Config\Inc;..\..\kernel\include;..\..\kernel\include\extend;..\..\kernel\source;..\..\libc\include\armlibc;..\..\common\ring_buff\include;..\..\common\ring_blk_buff\include;..\..\components\dlog\include;..\..\components\dlog\include\syslog;..\..\components\shell\include;..\..\components\atest\include;..\..\drivers;..\..\drivers\hal\st\hal_drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314,L6330
