# Keil uVision project template.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405OGYx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER
  c include: .;appplication;board;board\CubeMX_Config\Inc;..\..\kernel\include;..\..\kernel\include\extend;..\..\kernel\source;..\..\libc\include\armlibc;..\..\common\ring_buff\include;..\..\common\ring_blk_buff\include;..\..\components\dlog\include;..\..\components\dlog\include\syslog;..\..\components\shell\include;..\..\components\atest\include;..\..\drivers;..\..\drivers\hal\st\hal_drivers;..\..\drivers\hal\st\STM32F1xx_HAL\CMSIS\Include;..\..\drivers\hal\st\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;..\..\drivers\hal\st\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;..\..\drivers\hal\st\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc\Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314,L6330
