# Keil uVision project project.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: oneos +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, OS_USING_ARM_LIBC, STM32F407xx
  c include: .;application;..\..\arch\arm\armv7m\include;board;board\CubeMX_Config\Inc;board\ports;board\packages;..\..\common\include;..\..\components\dlog\include;..\..\drivers;..\..\drivers\block;..\..\drivers\bus;..\..\drivers\console;..\..\drivers\dma;..\..\drivers\fal;..\..\drivers\misc;..\..\drivers\pin;..\..\drivers\rtc;..\..\drivers\serial;..\..\drivers\spi;..\..\drivers\spi\sfud\inc;..\..\drivers\timer;..\..\drivers\watchdog;..\..\drivers\hal\st\devices;..\..\drivers\hal\st\drivers;..\..\drivers\hal\st\drivers\config;..\..\drivers\hal\st\drivers\drv_flash;..\..\drivers\hal\st\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\..\drivers\hal\st\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\..\drivers\hal\st\STM32F4xx_HAL\CMSIS\Include;..\..\kernel\include;..\..\libc\include;..\..\libc\include\extension;..\..\libc\include\armlibc;..\..\components\net\ip\lwip-2.1.2\src;..\..\components\net\ip\lwip-2.1.2\src\include;..\..\components\net\ip\lwip-2.1.2\src\include\netif;..\..\components\net\ip\lwip-2.1.2\src\port\arch\include;..\..\components\net\ip\lwip-2.1.2\src\port;..\..\components\diagnose\resource_moniter;..\..\components\shell\include;..\..\components\diagnose\stack_trace
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314,L6330
  group application
    application/: main.c
  group arch
    ../../arch/arm/armv7m/rvds/: arch_exception_rvds.S arch_task_switch_rvds.S
    ../../arch/arm/armv7m/: arch_task.c arch_exception.c arch_interrupt.c arch_misc.c
  group bsp
    board/: board.c
    board/CubeMX_Config/Src/: bsp.c stm32f4xx_it_bsp.c stm32f4xx_hal_msp.c system_stm32f4xx.c
    board/startup/: startup_stm32f407xx_arm.s
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group dlog
    ../../components/dlog/source/: dlog.c
    ../../components/dlog/source/backend/: console_backend.c
  group drivers
    ../../drivers/: driver.c device.c
    ../../drivers/block/: block.c
    ../../drivers/bus/: bus.c
    ../../drivers/console/: console.c
    ../../drivers/dma/: dma.c
    ../../drivers/fal/: fal.c fal_part.c
    ../../drivers/misc/: push_button.c adc.c dac.c
    ../../drivers/pin/: pin.c
    ../../drivers/rtc/: rtc.c
    ../../drivers/serial/: serial.c
    ../../drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../drivers/spi/flash/: fal_flash_sfud_port.c flash_spi.c
    ../../drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../drivers/timer/: timer.c clocksource.c clockevent.c hrtimer.c clocksource_cortexm.c
    ../../drivers/watchdog/: watchdog.c
  group hal/devices
    ../../drivers/hal/st/devices/: stm32_devices.c
  group hal/drivers
    ../../drivers/hal/st/drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_spi.c drv_eth.c drv_adc.c drv_dac.c drv_rtc.c drv_iwdg.c drv_sram.c drv_common.c
    ../../drivers/hal/st/drivers/drv_flash/: drv_flash_f4.c
  group hal/lowlevel
    ../../drivers/hal/st/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_spi.c stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_lptim.c stm32f4xx_hal_eth.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c
  group kernel
    ../../kernel/source/: os_block.c os_clock.c os_event.c os_idle.c os_kernel_lock.c os_kernel_log.c os_mb.c os_mem_firstfit.c os_mem_pool.c os_memory.c os_mq.c os_mutex.c os_sched.c os_sem.c os_spinlock.c os_startup.c os_task.c os_timer.c os_util.c os_version.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: chdir.c close.c dirent.c fcntl.c fstat.c getcwd.c libc.c libc_syms.c lseek.c mem_std.c mkdir.c open.c read.c rename.c stat.c statfs.c stdio.c stubs.c time.c unlink.c write.c
    ../../libc/source/common/: gmtime_r.c
  group lwip
    ../../components/net/ip/lwip-2.1.2/src/port/arch/: sys_arch.c
    ../../components/net/ip/lwip-2.1.2/src/core/: init.c def.c dns.c inet_chksum.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c altcp.c altcp_alloc.c altcp_tcp.c
    ../../components/net/ip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/ip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    ../../components/net/ip/lwip-2.1.2/src/port/netif/: ethernetif.c
    ../../components/net/ip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4_frag.c ip4.c ip4_addr.c
    ../../components/net/ip/lwip-2.1.2/src/apps/ping/: ping.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
