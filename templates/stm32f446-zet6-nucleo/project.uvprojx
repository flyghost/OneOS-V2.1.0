# Keil uVision project project.uvprojx, settings and files
target oneos (ARM-ADS)
  device: STM32F446ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: oneos
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F446xx, OS_USING_ARM_LIBC
  c include: .;application;..\..\components\atest\include;board;board\CubeMX_Config\Inc;board\ports;..\..\common\include;..\..\arch\arm\common;..\..\arch\arm\cortex-m4;..\..\components\diagnose\include;..\..\components\dlog\include;..\..\drivers;..\..\drivers\bus;..\..\drivers\dma;..\..\drivers\fal;..\..\drivers\i2c;..\..\drivers\misc;..\..\drivers\pin;..\..\drivers\rtc;..\..\drivers\serial;..\..\drivers\timer;..\..\drivers\usb\usbdevice;..\..\drivers\watchdog;..\..\drivers\hal\st\devices;..\..\drivers\hal\st\drivers;..\..\drivers\hal\st\drivers\config;..\..\drivers\hal\st\drivers\drv_flash;..\..\drivers\hal\st\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\..\drivers\hal\st\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\..\drivers\hal\st\STM32F4xx_HAL\CMSIS\Include;..\..\kernel\include;..\..\kernel\include\extend;..\..\libc\include;..\..\libc\include\armlibc;..\..\components\shell\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314,L6330
  group application
    application/: main.c
  group atest
    ../../components/atest/source/: atest.c
  group bsp
    board/: board.c
    board/CubeMX_Config/Src/: bsp.c stm32f4xx_it.c stm32f4xx_hal_msp.c system_stm32f4xx.c
    board/startup/: startup_stm32f446xx_arm.s
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group cpu
    ../../arch/arm/common/: cortexm_common.c
    ../../arch/arm/cortex-m4/: cpuport.c exc.c context_rvds.S
  group dlog
    ../../components/dlog/source/: dlog.c
    ../../components/dlog/source/backend/: backend_filesystem.c console_be.c
  group drivers
    ../../drivers/: os_drivers.c os_device.c
    ../../drivers/bus/: bus.c
    ../../drivers/dma/: os_dma.c
    ../../drivers/fal/: fal.c fal_part.c
    ../../drivers/i2c/: i2c.c
    ../../drivers/misc/: push_button.c adc.c dac.c
    ../../drivers/pin/: pin.c
    ../../drivers/rtc/: rtc.c
    ../../drivers/serial/: serial.c
    ../../drivers/timer/: timer.c clocksource.c clocksource_cortexm.c clockevent.c hrtimer.c
    ../../drivers/usb/usbdevice/core/: core.c usbdevice.c
    ../../drivers/usb/usbdevice/class/: hid.c
    ../../drivers/watchdog/: watchdog.c
  group hal/devices
    ../../drivers/hal/st/devices/: stm32_devices.c
  group hal/drivers
    ../../drivers/hal/st/drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_adc.c drv_dac.c drv_rtc.c drv_iwdg.c drv_common.c
    ../../drivers/hal/st/drivers/drv_flash/: drv_flash_f4.c
  group hal/lowlevel
    ../../drivers/hal/st/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_lptim.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c
  group kernel
    ../../kernel/source/: os_clock.c os_event.c os_idle.c os_ipc.c os_irq.c os_kernel_log.c os_mailbox.c os_mem_pool.c os_mem_small.c os_mq.c os_mutex.c os_object.c os_sem.c os_signal.c os_startup.c os_task.c os_timer.c os_util.c os_version.c
    ../../kernel/source/extend/: os_completion.c os_dataqueue.c os_waitqueue.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
    ../../libc/source/common/: gmtime_r.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
