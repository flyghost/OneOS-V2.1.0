# Keil uVision project project.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: project +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32F746xx, USE_HAL_DRIVER
  c include: .;application;..\..\arch\arm\armv7m\include;..\..\components\atest\include;board;board\CubeMX_Config\Inc;board\ports;..\..\common\include;..\..\components\dlog\include;..\..\drivers;..\..\drivers\bus;..\..\drivers\can;..\..\drivers\console;..\..\drivers\dma;..\..\drivers\fal;..\..\drivers\i2c;..\..\drivers\misc;..\..\drivers\mtd;..\..\drivers\pin;..\..\drivers\rtc;..\..\drivers\serial;..\..\drivers\timer;..\..\drivers\watchdog;..\..\components\fs\include;..\..\components\fs\include\devfs;..\..\drivers\hal\st\devices;..\..\drivers\hal\st\drivers;..\..\drivers\hal\st\drivers\config;..\..\drivers\hal\st\drivers\drv_flash;..\..\drivers\hal\st\STM32F7xx_HAL\STM32F7xx_HAL_Driver\Inc;..\..\drivers\hal\st\STM32F7xx_HAL\CMSIS\Device\ST\STM32F7xx\Include;..\..\drivers\hal\st\STM32F7xx_HAL\CMSIS\Include;..\..\kernel\include;..\..\libc\include;..\..\libc\include\extension;..\..\libc\include\armlibc;..\..\components\net\ip\lwip-2.1.2\src;..\..\components\net\ip\lwip-2.1.2\src\include;..\..\components\net\ip\lwip-2.1.2\src\include\netif;..\..\components\net\ip\lwip-2.1.2\src\port\arch\include;..\..\components\net\ip\lwip-2.1.2\src\port;..\..\components\diagnose\resource_moniter;..\..\components\shell\include;..\..\components\diagnose\stack_trace
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314,L6330
  group application
    application/: main.c
  group arch
    ../../arch/arm/armv7m/rvds/: arch_exception_rvds.S arch_task_switch_rvds.S
    ../../arch/arm/armv7m/: arch_cache.c arch_task.c arch_exception.c arch_interrupt.c arch_misc.c arch_atomic.c
  group atest
    ../../components/atest/source/: atest.c
  group bsp
    board/: board.c
    board/CubeMX_Config/Src/: bsp.c stm32f7xx_it_bsp.c stm32f7xx_hal_msp.c system_stm32f7xx.c
    board/startup/: startup_stm32f746xx_arm.s
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group dlog
    ../../components/dlog/source/: dlog.c
    ../../components/dlog/source/backend/: console_backend.c
  group drivers
    ../../drivers/: driver.c device.c
    ../../drivers/block/: block_device.c
    ../../drivers/bus/: bus.c
    ../../drivers/can/: can.c
    ../../drivers/console/: console.c
    ../../drivers/dma/: dma.c
    ../../drivers/fal/: fal.c fal_part.c fal_mtd.c fal_block.c
    ../../drivers/i2c/: i2c.c
    ../../drivers/misc/: push_button.c adc.c dac.c
    ../../drivers/mtd/: mtd.c
    ../../drivers/pin/: pin.c
    ../../drivers/rtc/: rtc.c
    ../../drivers/serial/: serial.c
    ../../drivers/timer/: timer.c clocksource.c clockevent.c hrtimer.c clocksource_cortexm.c
    ../../drivers/watchdog/: watchdog.c
  group filesystem
    ../../components/fs/source/: fs_cmd.c vfs.c vfs_fd.c vfs_fs.c vfs_misc.c vfs_posix.c
    ../../components/fs/source/devfs/: vfs_devfs.c
  group hal/devices
    ../../drivers/hal/st/devices/: stm32_devices.c
  group hal/drivers
    ../../drivers/hal/st/drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_i2c.c drv_eth.c drv_adc.c drv_dac.c drv_can.c drv_rtc.c drv_iwdg.c drv_common.c
    ../../drivers/hal/st/drivers/flash/: drv_flash_f7.c
  group hal/lowlevel
    ../../drivers/hal/st/STM32F7xx_HAL/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_sram.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_usart.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_hcd.c stm32f7xx_ll_usb.c stm32f7xx_hal_can.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_lptim.c stm32f7xx_hal_eth.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c
  group kernel
    ../../kernel/source/: os_block.c os_clock.c os_event.c os_idle.c os_kernel_lock.c os_kernel_log.c os_mb.c os_mem_firstfit.c os_mem_pool.c os_memory.c os_mq.c os_mutex.c os_sched.c os_sem.c os_spinlock.c os_startup.c os_task.c os_timer.c os_util.c os_version.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: access.c chdir.c close.c dirent.c fcntl.c fstat.c fsync.c getcwd.c ioctl.c libc.c lseek.c mem_std.c mkdir.c open.c read.c rename.c rmdir.c stat.c statfs.c stdio.c strdup.c strnlen.c stubs.c time.c unlink.c write.c
    ../../libc/source/common/: gmtime_r.c
  group lwip
    ../../components/net/ip/lwip-2.1.2/src/port/arch/: sys_arch.c
    ../../components/net/ip/lwip-2.1.2/src/core/: init.c def.c dns.c inet_chksum.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c altcp.c altcp_alloc.c altcp_tcp.c
    ../../components/net/ip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/ip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    ../../components/net/ip/lwip-2.1.2/src/port/netif/: ethernetif.c
    ../../components/net/ip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4_frag.c ip4.c ip4_addr.c
    ../../components/net/ip/lwip-2.1.2/src/apps/ping/: ping.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
