# Keil uVision project template.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H742BITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00057000) IROM(0x08000000,0x00200000) XRAM(0x30000000,0x00008000) XRAM2(0x30020000,0x00004000) XRAM3(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F743xx
  c include: .;appplication;board;board\CubeMX_Config\Inc;..\..\kernel\include;..\..\kernel\include\extend;..\..\kernel\source;..\..\libc\include\armlibc;..\..\common\ring_buff\include;..\..\common\ring_blk_buff\include;..\..\components\dlog\include;..\..\components\dlog\include\syslog;..\..\components\shell\include;..\..\components\atest\include;..\..\drivers;..\..\drivers\hal\st\hal_drivers;..\..\drivers\hal\st\STM32H7xx_HAL\CMSIS\Include;..\..\drivers\hal\st\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;..\..\drivers\hal\st\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;..\..\drivers\hal\st\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc\Legacy
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: ROM 0x30000000 size 0x8000
  memory RVCT7: ROM 0x30020000 size 0x4000
  memory RVCT8: ROM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x57000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314,L6330
