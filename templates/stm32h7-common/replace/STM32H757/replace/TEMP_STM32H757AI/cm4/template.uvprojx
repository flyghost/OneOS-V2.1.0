# Keil uVision project template.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H757AIIx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.0
  cpu: IRAM(0x10000000,0x00030000) IRAM2(0x10040000,0x00008000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_CM4,USE_HAL_DRIVER,STM32H747xx
  c include: .;..\appplication;board;..\common\CubeMX_Config\CM4\Inc;..\..\..\kernel\include;..\..\..\kernel\include\extend;..\..\..\kernel\source;..\..\..\libc\include\armlibc;..\..\..\common\ring_buff\include;..\..\..\common\ring_blk_buff\include;..\..\..\components\dlog\include;..\..\..\components\dlog\include\syslog;..\..\..\components\shell\include;..\..\..\components\atest\include;..\..\..\drivers;..\..\..\drivers\hal\st\hal_drivers;..\..\..\drivers\hal\st\STM32H7xx_HAL\CMSIS\Include;..\..\..\drivers\hal\st\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;..\..\..\drivers\hal\st\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;..\..\..\drivers\hal\st\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc\Legacy
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x30000
  memory RVCT10: RAM 0x10040000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314,L6330
