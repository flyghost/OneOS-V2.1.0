# Keil uVision project project.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OS_TASK_SWITCH_NOTIFY, CORE_CM7, USE_HAL_DRIVER, STM32H747xx
  c include: .;application;..\..\..\arch\arm\armv7m\include;..\..\..\components\atest\include;board;..\common\CubeMX_Config\CM7\Inc;board\ports;..\..\..\components\cli\include;..\..\..\osal\cmsis\include;..\..\..\common\include;..\..\..\components\dlog\include;..\..\..\drivers;..\..\..\drivers\bus;..\..\..\drivers\console;..\..\..\drivers\dma;..\..\..\drivers\fal;..\..\..\drivers\i2c;..\..\..\drivers\misc;..\..\..\drivers\mtd;..\..\..\drivers\pin;..\..\..\drivers\rtc;..\..\..\drivers\serial;..\..\..\drivers\spi;..\..\..\drivers\spi\sfud\inc;..\..\..\drivers\timer;..\..\..\drivers\watchdog;..\..\..\osal\freertos\include;..\..\..\drivers\hal\st\devices;..\..\..\drivers\hal\st\drivers;..\..\..\drivers\hal\st\drivers\config;..\..\..\drivers\hal\st\drivers\drv_flash;..\..\..\drivers\hal\st\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;..\..\..\drivers\hal\st\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;..\..\..\drivers\hal\st\STM32H7xx_HAL\CMSIS\Include;..\..\..\kernel\include;..\..\..\libc\include;..\..\..\libc\include\extension;..\..\..\libc\include\armlibc;..\..\..\components\net\molink\api\include;..\..\..\components\net\molink\core\include;..\..\..\components\net\molink\module\ec20\include;..\..\..\components\net\molink\parser\include;..\..\..\components\net\molink\tools\include;..\..\..\components\position;..\..\..\components\position\ble_pos\onepos_engine;..\..\..\components\position\ble_pos\onepos_engine\ope_base_calculate;..\..\..\components\position\ble_pos\onepos_engine\ope_base_funtion;..\..\..\components\position\ble_pos\onepos_engine\ope_base_funtion\ope_position_lib;..\..\..\components\position\ble_pos\onepos_engine\ope_base_funtion\ope_position_lib\ope_general_lib;..\..\..\components\position\gnss_pos;..\..\..\components\position\gnss_pos\prot;..\..\..\components\position\gnss_pos\rcvr;..\..\..\components\position\net_pos;..\..\..\components\shell\include;..\..\..\components\diagnose\stack_trace;..\..\..\drivers\usb\usb_host;..\..\..\drivers\usb\usb_host\Core\Inc;..\..\..\drivers\usb\usb_host\Class\HID\Inc;..\..\..\drivers\usb\usb_host\Class\Specific_CDC\Inc
  asm define: OS_TASK_SWITCH_NOTIFY
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314,L6330
  group application
    application/: main.c
  group arch
    ../../../arch/arm/armv7m/rvds/: arch_exception_rvds.S arch_task_switch_rvds.S
    ../../../arch/arm/armv7m/: arch_cache.c arch_task.c arch_exception.c arch_interrupt.c arch_misc.c arch_atomic.c
  group atest
    ../../../components/atest/source/: atest.c
  group bsp
    board/: board.c
    ../common/CubeMX_Config/CM7/Src/: bsp.c stm32h7xx_it_bsp.c stm32h7xx_hal_msp.c
    ../common/CubeMX_Config/Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
    board/startup/: startup_stm32h747xx_arm.s
    ../../../demos/driver/: usbh_cdc_test.c
  group cmsis
    ../../../osal/cmsis/source/: cmsis_event.c cmsis_kernel.c cmsis_mp.c cmsis_mq.c cmsis_mutex.c cmsis_sem.c cmsis_thread.c cmsis_timer.c os_systick.c
  group common
    ../../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group dlog
    ../../../components/dlog/source/: dlog.c
    ../../../components/dlog/source/backend/: console_backend.c
  group drivers
    ../../../drivers/: driver.c device.c
    ../../../drivers/block/: block_device.c
    ../../../drivers/bus/: bus.c
    ../../../drivers/console/: console.c
    ../../../drivers/dma/: dma_ram.c soft_dma.c
    ../../../drivers/fal/: fal.c fal_part.c fal_mtd.c fal_block.c
    ../../../drivers/i2c/: i2c.c
    ../../../drivers/misc/: push_button.c adc.c dac.c
    ../../../drivers/mtd/: mtd.c
    ../../../drivers/pin/: pin.c
    ../../../drivers/rtc/: rtc.c
    ../../../drivers/serial/: serial.c
    ../../../drivers/spi/: spi_core.c spi_dev.c qspi_core.c spi_flash_sfud.c
    ../../../drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../drivers/timer/: timer.c clocksource.c clockevent.c hrtimer.c clocksource_cortexm.c
    ../../../drivers/watchdog/: watchdog.c
  group freertos
    ../../../osal/freertos/source/: event_port.c freertos_internal.c mem_port.c queue_port.c tasks_port.c timer_port.c
  group hal/devices
    ../../../drivers/hal/st/devices/: stm32_devices.c
  group hal/drivers
    ../../../drivers/hal/st/drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_qspi.c drv_rtc.c drv_iwdg.c drv_usbh.c drv_common.c
    ../../../drivers/hal/st/drivers/flash/: drv_flash_h7.c
  group hal/lowlevel
    ../../../drivers/hal/st/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cec.c stm32h7xx_hal_cortex.c stm32h7xx_hal_comp.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_sram.c stm32h7xx_hal_gpio.c stm32h7xx_hal_exti.c stm32h7xx_hal_hsem.c stm32h7xx_hal_uart.c stm32h7xx_hal_usart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_hcd.c stm32h7xx_ll_usb.c stm32h7xx_hal_tim.c stm32h7xx_ll_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c
  group kernel
    ../../../kernel/source/: os_block.c os_clock.c os_event.c os_idle.c os_kernel_lock.c os_kernel_log.c os_mb.c os_mem_firstfit.c os_mem_pool.c os_memory.c os_mq.c os_mutex.c os_sched.c os_sem.c os_spinlock.c os_startup.c os_task.c os_timer.c os_util.c os_version.c os_workqueue.c
  group libc
    ../../../libc/source/armlibc/: access.c chdir.c close.c dirent.c fcntl.c fstat.c fsync.c getcwd.c ioctl.c libc.c lseek.c mem_std.c mkdir.c open.c read.c rename.c rmdir.c stat.c statfs.c stdio.c strdup.c strnlen.c stubs.c time.c unlink.c write.c
    ../../../libc/source/common/: gmtime_r.c
  group molink
    ../../../components/net/molink/api/source/: mo_common.c mo_factory.c mo_general.c mo_netserv.c mo_ping.c mo_ifconfig.c mo_netconn.c mo_socket.c
    ../../../components/net/molink/core/source/: mo_object.c mo_lib.c mo_ipaddr.c mo_time.c
    ../../../components/net/molink/module/ec20/source/: ec20.c ec20_general.c ec20_netserv.c ec20_ping.c ec20_ifconfig.c ec20_netconn.c
    ../../../components/net/molink/parser/source/: at_parser.c at_resp.c at_printf.c
    ../../../components/net/molink/tools/source/: tool.c
  group shell
    ../../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
  group usb_host
    ../../../drivers/usb/usb_host/Core/Src/: proto_usbh_core.c proto_usbh_ctlreq.c proto_usbh_ioreq.c proto_usbh_pipes.c
    ../../../drivers/usb/usb_host/Class/HID/Src/: usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
    ../../../drivers/usb/usb_host/: usbh_cdc_dev.c
    ../../../drivers/usb/usb_host/Class/Specific_CDC/Src/: usbh_specific_cdc.c
