# Keil uVision project template.uvprojx, settings and files
target oneos (ARM-ADS)
  device: STM32L162RETx STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00014000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L072xx
  c include: .;appplication;board;board\CubeMX_Config\Inc;..\..\kernel\include;..\..\kernel\include\extend;..\..\kernel\source;..\..\libc\include\armlibc;..\..\common\ring_buff\include;..\..\common\ring_blk_buff\include;..\..\components\dlog\include;..\..\components\dlog\include\syslog;..\..\components\shell\include;..\..\components\atest\include;..\..\drivers;..\..\drivers\hal\st\hal_drivers;..\..\drivers\hal\st\STM32F0xx_HAL\CMSIS\Include;..\..\drivers\hal\st\STM32F0xx_HAL\CMSIS\Device\ST\STM32F0xx\Include;..\..\drivers\hal\st\STM32F0xx_HAL\STM32F0xx_HAL_Driver\Inc;..\..\drivers\hal\st\STM32F0xx_HAL\STM32F0xx_HAL_Driver\Inc\Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314,L6330
