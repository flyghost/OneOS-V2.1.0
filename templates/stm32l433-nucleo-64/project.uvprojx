# Keil uVision project project.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L433RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L433xx, USE_HAL_DRIVER
  c include: .;application;..\..\arch\arm\armv7m\include;..\..\components\atest\include;board;board\CubeMX_Config\Inc;board\ports;..\..\common\include;..\..\components\dlog\include;..\..\drivers;..\..\drivers\bus;..\..\drivers\console;..\..\drivers\dma;..\..\drivers\fal;..\..\drivers\i2c;..\..\drivers\misc;..\..\drivers\mtd;..\..\drivers\pin;..\..\drivers\rtc;..\..\drivers\serial;..\..\drivers\spi;..\..\drivers\timer;..\..\drivers\watchdog;..\..\drivers\hal\st\devices;..\..\drivers\hal\st\drivers;..\..\drivers\hal\st\drivers\config;..\..\drivers\hal\st\drivers\drv_flash;..\..\drivers\hal\st\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Inc;..\..\drivers\hal\st\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Include;..\..\drivers\hal\st\STM32L4xx_HAL\CMSIS\Include;..\..\kernel\include;..\..\libc\include;..\..\libc\include\extension;..\..\libc\include\armlibc;..\..\components\diagnose\resource_moniter;..\..\components\shell\include;..\..\components\diagnose\stack_trace
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314,L6330
  group application
    application/: main.c
  group arch
    ../../arch/arm/armv7m/rvds/: arch_exception_rvds.S arch_task_switch_rvds.S
    ../../arch/arm/armv7m/: arch_task.c arch_exception.c arch_interrupt.c arch_misc.c arch_atomic.c
  group atest
    ../../components/atest/source/: atest.c
  group bsp
    board/: board.c
    board/CubeMX_Config/Src/: bsp.c stm32l4xx_it_bsp.c stm32l4xx_hal_msp.c system_stm32l4xx.c
    board/startup/: startup_stm32l433xx_arm.s
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group dlog
    ../../components/dlog/source/: dlog.c
    ../../components/dlog/source/backend/: console_backend.c
  group drivers
    ../../drivers/: driver.c device.c
    ../../drivers/block/: block_device.c
    ../../drivers/bus/: bus.c
    ../../drivers/console/: console.c
    ../../drivers/dma/: dma.c
    ../../drivers/fal/: fal.c fal_part.c fal_mtd.c fal_block.c
    ../../drivers/i2c/: i2c.c
    ../../drivers/misc/: push_button.c adc.c dac.c
    ../../drivers/mtd/: mtd.c
    ../../drivers/pin/: pin.c
    ../../drivers/rtc/: rtc.c
    ../../drivers/serial/: serial.c
    ../../drivers/spi/: spi_core.c spi_dev.c
    ../../drivers/timer/: timer.c clocksource.c clockevent.c clocksource_cortexm.c
    ../../drivers/watchdog/: watchdog.c
  group hal/devices
    ../../drivers/hal/st/devices/: stm32_devices.c
  group hal/drivers
    ../../drivers/hal/st/drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_spi.c drv_adc.c drv_dac.c drv_lptim.c drv_rtc.c drv_iwdg.c drv_common.c
    ../../drivers/hal/st/drivers/flash/: drv_flash_l4.c
  group hal/lowlevel
    ../../drivers/hal/st/STM32L4xx_HAL/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_gpio.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_can.c stm32l4xx_hal_lptim.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c
  group kernel
    ../../kernel/source/: os_block.c os_clock.c os_event.c os_idle.c os_kernel_lock.c os_kernel_log.c os_mb.c os_mem_firstfit.c os_mem_pool.c os_memory.c os_mq.c os_mutex.c os_sched.c os_sem.c os_spinlock.c os_startup.c os_task.c os_timer.c os_util.c os_version.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: access.c chdir.c close.c dirent.c fcntl.c fstat.c fsync.c getcwd.c ioctl.c libc.c lseek.c mem_std.c mkdir.c open.c read.c rename.c rmdir.c stat.c statfs.c stdio.c strdup.c strnlen.c stubs.c time.c unlink.c write.c
    ../../libc/source/common/: gmtime_r.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
