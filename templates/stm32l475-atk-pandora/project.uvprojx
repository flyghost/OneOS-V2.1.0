# Keil uVision project project.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: oneos +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32L475xx, USE_HAL_DRIVER
  c include: .;application;..\..\arch\arm\armv7m\include;..\..\drivers\audio;board;board\CubeMX_Config\Inc;board\ports;board\packages;..\..\common\include;..\..\components\dlog\include;..\..\components\dlog\include\syslog;..\..\drivers;..\..\drivers\bus;..\..\drivers\console;..\..\drivers\fal;..\..\drivers\hal\st\drivers;..\..\drivers\i2c;..\..\drivers\misc;..\..\drivers\mtd;..\..\drivers\pin;..\..\drivers\serial;..\..\drivers\spi;..\..\drivers\spi\sfud\inc;..\..\drivers\timer;..\..\drivers\watchdog;..\..\components\fs\include;..\..\components\fs\include\devfs;..\..\components\fs\include\fatfs;..\..\drivers\graphic;..\..\drivers\hal\st\devices;..\..\drivers\hal\st\drivers;..\..\drivers\hal\st\drivers\config;..\..\drivers\hal\st\drivers\drv_flash;..\..\drivers\hal\st\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Inc;..\..\drivers\hal\st\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Include;..\..\drivers\hal\st\STM32L4xx_HAL\CMSIS\Include;..\..\drivers\infrared;..\..\kernel\include;..\..\libc\include;..\..\libc\include\extension;..\..\libc\include\armlibc;..\..\components\net\ip\lwip-2.1.2\src;..\..\components\net\ip\lwip-2.1.2\src\include;..\..\components\net\ip\lwip-2.1.2\src\include\netif;..\..\components\net\ip\lwip-2.1.2\src\port\arch\include;..\..\components\net\ip\lwip-2.1.2\src\port;..\..\thirdparty\mpu6xxx\inc;..\..\components\diagnose\resource_moniter;..\..\drivers\sensors;..\..\components\shell\include;..\..\components\diagnose\stack_trace
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314,L6330
  group application
    application/: main.c
  group arch
    ../../arch/arm/armv7m/rvds/: arch_exception_rvds.S arch_task_switch_rvds.S
    ../../arch/arm/armv7m/: arch_task.c arch_exception.c arch_interrupt.c arch_misc.c arch_atomic.c
  group audio
    ../../drivers/audio/: audio_player.c audio_recorder.c sai.c es8388.c es8388_ll.c
  group bsp
    board/: board.c
    board/CubeMX_Config/Src/: bsp.c stm32l4xx_it_bsp.c stm32l4xx_hal_msp.c system_stm32l4xx.c
    board/startup/: startup_stm32l475xx_arm.s
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group dlog
    ../../components/dlog/source/: dlog.c
    ../../components/dlog/source/backend/: console_backend.c
    ../../components/dlog/source/syslog/: syslog.c
  group drivers
    ../../drivers/: driver.c device.c
    ../../drivers/block/: block_device.c
    ../../drivers/bus/: bus.c
    ../../drivers/console/: console.c
    ../../drivers/fal/: fal.c fal_part.c fal_mtd.c fal_block.c
    ../../drivers/hal/st/drivers/usb/usbdevice/core/: core.c usbdevice.c
    ../../drivers/hal/st/drivers/usb/usbdevice/class/: hid.c
    ../../drivers/i2c/: i2c.c soft_i2c_bus.c soft_i2c_bus_config.c
    ../../drivers/misc/: push_button.c adc.c dac.c pwm.c
    ../../drivers/mtd/: mtd.c
    ../../drivers/pin/: pin.c
    ../../drivers/serial/: serial.c
    ../../drivers/spi/: spi_core.c spi_dev.c qspi_core.c enc28j60.c spi_msd.c spi_tfcard.c spi_flash_sfud.c
    ../../drivers/spi/flash/: flash_qspi.c fal_flash_sfud_port.c
    ../../drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../drivers/timer/: timer.c clocksource.c clockevent.c hrtimer.c clocksource_cortexm.c
    ../../drivers/watchdog/: watchdog.c
  group filesystem
    ../../components/fs/source/: fs_cmd.c vfs.c vfs_fd.c vfs_fs.c vfs_misc.c vfs_poll.c vfs_posix.c vfs_select.c
    ../../components/fs/source/devfs/: vfs_devfs.c
    ../../components/fs/source/fatfs/: diskio.c ff.c syscall.c unicode.c vfs_fatfs.c
  group graphic
    ../../drivers/graphic/: graphic.c st7789vw.c
  group hal/devices
    ../../drivers/hal/st/devices/: stm32_devices.c
  group hal/drivers
    ../../drivers/hal/st/drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_pwm.c drv_spi.c drv_qspi.c drv_adc.c drv_dac.c drv_lptim.c drv_iwdg.c drv_usbd.c drv_sai.c drv_common.c
    ../../drivers/hal/st/drivers/flash/: drv_flash_l4.c
  group hal/lowlevel
    ../../drivers/hal/st/STM32L4xx_HAL/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_gpio.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_hcd.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal_can.c stm32l4xx_hal_lptim.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c
  group infrared
    ../../drivers/infrared/: infrared.c remote_control_atk.c
  group kernel
    ../../kernel/source/: os_block.c os_clock.c os_event.c os_idle.c os_kernel_lock.c os_kernel_log.c os_mb.c os_mem_firstfit.c os_mem_pool.c os_memory.c os_mq.c os_mutex.c os_sched.c os_sem.c os_spinlock.c os_startup.c os_task.c os_timer.c os_util.c os_version.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: access.c chdir.c close.c dirent.c fcntl.c fstat.c fsync.c getcwd.c ioctl.c libc.c lseek.c mem_std.c mkdir.c open.c poll.c read.c rename.c rmdir.c select.c stat.c statfs.c stdio.c strdup.c strnlen.c stubs.c time.c unlink.c write.c
    ../../libc/source/common/: gmtime_r.c
  group lwip
    ../../components/net/ip/lwip-2.1.2/src/port/arch/: sys_arch.c
    ../../components/net/ip/lwip-2.1.2/src/core/: init.c def.c dns.c inet_chksum.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c altcp.c altcp_alloc.c altcp_tcp.c
    ../../components/net/ip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/ip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    ../../components/net/ip/lwip-2.1.2/src/port/netif/: ethernetif.c
    ../../components/net/ip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4_frag.c ip4.c ip4_addr.c
    ../../components/net/ip/lwip-2.1.2/src/apps/ping/: ping.c
  group mpu6xxx
    ../../thirdparty/mpu6xxx/src/: mpu6xxx.c sensor_inven_mpu6xxx.c
  group sensors
    ../../drivers/sensors/: sensor.c mpu6xxx_port.c ap3216c.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
