# Keil uVision project project.uvprojx, settings and files
target oneos (ARM-ADS)
  device: STM32L496VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: oneos +hex
  AfterMake: fromelf --bin !L --output oneos.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L496xx, OS_USING_ARM_LIBC, USE_HAL_DRIVER
  c include: .;application;..\..\components\atest\include;..\..\drivers\audio;board;board\CubeMX_Config\Inc;board\ports;..\..\common\include;..\..\arch\arm\common;..\..\arch\arm\cortex-m4;..\..\components\diagnose\include;..\..\components\dlog\include;..\..\drivers;..\..\drivers\bus;..\..\drivers\dma;..\..\drivers\fal;..\..\drivers\i2c;..\..\drivers\misc;..\..\drivers\pin;..\..\drivers\rtc;..\..\drivers\sdio;..\..\drivers\serial;..\..\drivers\spi;..\..\drivers\timer;..\..\drivers\usb\usbdevice;..\..\drivers\watchdog;..\..\components\fs\include;..\..\components\fs\include\devfs;..\..\components\fs\include\fatfs;..\..\drivers\graphic;..\..\drivers\hal\st\devices;..\..\drivers\hal\st\drivers;..\..\drivers\hal\st\drivers\config;..\..\drivers\hal\st\drivers\drv_flash;..\..\drivers\hal\st\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Inc;..\..\drivers\hal\st\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Include;..\..\drivers\hal\st\STM32L4xx_HAL\CMSIS\Include;..\..\kernel\include;..\..\kernel\include\extend;..\..\libc\include;..\..\libc\include\armlibc;..\..\drivers\sensors;..\..\components\shell\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314,L6330
  group application
    application/: main.c
  group atest
    ../../components/atest/source/: atest.c
  group audio
    ../../drivers/audio/: audio_player.c audio_recorder.c audio_pipe.c sai.c isd9160.c
  group bsp
    board/: board.c
    board/CubeMX_Config/Src/: bsp.c stm32l4xx_it.c stm32l4xx_hal_msp.c system_stm32l4xx.c
    board/startup/: startup_stm32l496xx_arm.s
  group common
    ../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group cpu
    ../../arch/arm/common/: cortexm_common.c
    ../../arch/arm/cortex-m4/: cpuport.c exc.c context_rvds.S
  group dlog
    ../../components/dlog/source/: dlog.c
    ../../components/dlog/source/backend/: backend_filesystem.c console_be.c
  group drivers
    ../../drivers/: os_drivers.c os_device.c
    ../../drivers/bus/: bus.c
    ../../drivers/dma/: os_dma.c
    ../../drivers/fal/: fal.c fal_part.c fal_block.c
    ../../drivers/i2c/: i2c.c soft_i2c_bus.c soft_i2c_bus_config.c
    ../../drivers/misc/: push_button.c adc.c dac.c
    ../../drivers/pin/: pin.c
    ../../drivers/rtc/: rtc.c
    ../../drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    ../../drivers/serial/: serial.c
    ../../drivers/spi/: spi_core.c spi_dev.c qspi_core.c
    ../../drivers/timer/: timer.c clocksource.c clocksource_cortexm.c clockevent.c hrtimer.c
    ../../drivers/usb/usbdevice/core/: core.c usbdevice.c
    ../../drivers/usb/usbdevice/class/: hid.c
    ../../drivers/watchdog/: watchdog.c
  group filesystem
    ../../components/fs/source/: fs_cmd.c poll.c select.c vfs.c vfs_file.c vfs_fs.c vfs_posix.c
    ../../components/fs/source/devfs/: vfs_devfs.c
    ../../components/fs/source/fatfs/: diskio.c ff.c syscall.c unicode.c vfs_fatfs.c
  group graphic
    ../../drivers/graphic/: graphic.c st7789vw.c
  group hal/devices
    ../../drivers/hal/st/devices/: stm32_devices.c
  group hal/drivers
    ../../drivers/hal/st/drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_spi.c drv_qspi.c drv_adc.c drv_dac.c drv_lptim.c drv_rtc.c drv_iwdg.c drv_sdio.c drv_usbd.c drv_sai.c drv_common.c
    ../../drivers/hal/st/drivers/drv_flash/: drv_flash_l4.c
  group hal/lowlevel
    ../../drivers/hal/st/STM32L4xx_HAL/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_gpio.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_hcd.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal_lptim.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c
  group kernel
    ../../kernel/source/: os_clock.c os_event.c os_idle.c os_ipc.c os_irq.c os_kernel_log.c os_mailbox.c os_mem_pool.c os_mem_small.c os_mq.c os_mutex.c os_object.c os_sem.c os_signal.c os_startup.c os_task.c os_timer.c os_util.c os_version.c
    ../../kernel/source/extend/: os_completion.c os_dataqueue.c os_waitqueue.c os_workqueue.c
  group libc
    ../../libc/source/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
    ../../libc/source/common/: gmtime_r.c
  group sensors
    ../../drivers/sensors/: sensor.c lsm6dsl.c
  group shell
    ../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
