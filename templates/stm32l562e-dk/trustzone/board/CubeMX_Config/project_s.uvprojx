# Keil uVision project project_s.uvprojx, settings and files
target TrustZone_S (6140000::V6.14::ARMCLANG)
  device: STM32L562QEIxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: oneos +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L562xx
  c include: Secure\Inc;Secure_nsclib;..\..\..\..\..\drivers\hal\st\STM32L5xx_HAL\STM32L5xx_HAL_Driver\Inc;..\..\..\..\..\drivers\hal\st\STM32L5xx_HAL\CMSIS\Device\ST\STM32L5xx\Include;..\..\..\..\..\drivers\hal\st\STM32L5xx_HAL\STM32L5xx_HAL_Driver\Inc\Legacy;..\..\..\..\..\drivers\hal\st\STM32L5xx_HAL\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x30000000 size 0x40000
  scatter file: ..\linker_scripts\stm32l562xe_flash_s.sct
  link misc: --import_cmse_lib_out=Secure_nsclib/secure_nsclib.o
  group Application/MDK-ARM
    ../startup/: startup_stm32l562xx_arm.s
  group Application/User/Secure
    ./Secure/Src/: main.c secure_nsc.c stm32l5xx_hal_msp.c stm32l5xx_it.c tz_context.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../drivers/hal/st/STM32L5xx_HAL/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal_gtzc.c stm32l5xx_hal.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_cortex.c stm32l5xx_hal_icache.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c stm32l5xx_hal_rtc.c stm32l5xx_hal_rtc_ex.c
  group Drivers/CMSIS
    ./Secure/Src/: system_stm32l5xx_s.c
  group arch
    ../../../../../arch/arm/armv8m/trustzone/rvds/: arch_exc_rvds_secure.S
    ../../../../../arch/arm/armv8m/trustzone/: arch_exc_secure.c
