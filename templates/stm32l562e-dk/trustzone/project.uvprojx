# Keil uVision project project.uvprojx, settings and files
target oneos_ns (6140000::V6.14::ARMCLANG)
  device: STM32L562QEIxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: oneos +hex
  AfterMake: fromelf --bin !L --output oneos_ns.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: OS_TASK_SWITCH_NOTIFY, STM32L562xx, USE_HAL_DRIVER
  c include: .;application;..\..\..\arch\arm\armv8m\include;..\..\..\arch\arm\armv8m\trustzone;board;board\CubeMX_Config\NonSecure\Inc;board\CubeMX_Config\Secure_nsclib;board\ports;..\..\..\components\cli\include;..\..\..\common\include;..\..\..\components\dlog\include;..\..\..\drivers;..\..\..\drivers\boot\cotex-m;..\..\..\drivers\bus;..\..\..\drivers\console;..\..\..\drivers\dma;..\..\..\drivers\fal;..\..\..\drivers\i2c;..\..\..\drivers\misc;..\..\..\drivers\mtd;..\..\..\drivers\pin;..\..\..\drivers\rtc;..\..\..\drivers\serial;..\..\..\drivers\timer;..\..\..\drivers\watchdog;..\..\..\drivers\hal\st\devices;..\..\..\drivers\hal\st\drivers;..\..\..\drivers\hal\st\drivers\config;..\..\..\drivers\hal\st\STM32L5xx_HAL\STM32L5xx_HAL_Driver\Inc;..\..\..\drivers\hal\st\STM32L5xx_HAL\CMSIS\Device\ST\STM32L5xx\Include;..\..\..\drivers\hal\st\STM32L5xx_HAL\CMSIS\Include;..\..\..\kernel\include;..\..\..\libc\include;..\..\..\libc\include\extension;..\..\..\libc\include\armlibc;..\..\..\components\position;..\..\..\components\position\ble_pos\onepos_engine;..\..\..\components\position\ble_pos\onepos_engine\ope_base_calculate;..\..\..\components\position\ble_pos\onepos_engine\ope_base_funtion;..\..\..\components\position\ble_pos\onepos_engine\ope_base_funtion\ope_position_lib;..\..\..\components\position\ble_pos\onepos_engine\ope_base_funtion\ope_position_lib\ope_general_lib;..\..\..\components\position\gnss_pos;..\..\..\components\position\gnss_pos\prot;..\..\..\components\position\gnss_pos\rcvr;..\..\..\components\position\gnss_pos\rtk;..\..\..\components\position\net_pos;..\..\..\drivers\sensors;..\..\..\components\shell\include;..\..\..\components\diagnose\stack_trace
  asm define: OS_TASK_SWITCH_NOTIFY
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\board\linker_scripts\stm32l562xe_flash_ns.sct
  link misc: board/CubeMX_Config/Secure_nsclib/secure_nsclib.o  --diag_suppress L6314,L6330
  group application
    application/: main.c
  group arch
    ../../../arch/arm/armv8m/: arch_atomic.c arch_interrupt.c arch_misc.c
    ../../../arch/arm/armv8m/trustzone/rvds/: arch_syscall_rvds.S arch_task_switch_rvds.S
    ../../../arch/arm/armv8m/trustzone/: arch_exc_nonsecure.c arch_secure.c arch_task.c
  group bsp
    board/: board.c
    board/CubeMX_Config/NonSecure/Src/: bsp.c stm32l5xx_it_bsp.c stm32l5xx_hal_msp.c system_stm32l5xx_ns.c
    board/startup/: startup_stm32l562xx_arm.s
  group common
    ../../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group dlog
    ../../../components/dlog/source/: dlog.c
    ../../../components/dlog/source/backend/: console_backend.c
  group drivers
    ../../../drivers/: driver.c device.c
    ../../../drivers/block/: block_device.c
    ../../../drivers/boot/cotex-m/: vector_table.c
    ../../../drivers/bus/: bus.c
    ../../../drivers/console/: console.c
    ../../../drivers/dma/: dma_ram.c soft_dma.c
    ../../../drivers/fal/: fal.c fal_part.c fal_mtd.c fal_block.c
    ../../../drivers/i2c/: i2c.c soft_i2c_bus.c soft_i2c_bus_config.c
    ../../../drivers/misc/: push_button.c adc.c dac.c pwm.c
    ../../../drivers/mtd/: mtd.c
    ../../../drivers/pin/: pin.c
    ../../../drivers/rtc/: rtc.c
    ../../../drivers/serial/: serial.c
    ../../../drivers/timer/: timer.c clocksource.c clockevent.c hrtimer.c clocksource_cortexm.c
    ../../../drivers/watchdog/: watchdog.c
  group hal/devices
    ../../../drivers/hal/st/devices/: stm32_devices.c
  group hal/drivers
    ../../../drivers/hal/st/drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_pwm.c drv_adc.c drv_dac.c drv_rtc.c drv_iwdg.c drv_common.c
    ../../../drivers/hal/st/drivers/flash/: drv_flash_l5.c
  group hal/lowlevel
    ../../../drivers/hal/st/STM32L5xx_HAL/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_comp.c stm32l5xx_hal_cortex.c stm32l5xx_hal_crc.c stm32l5xx_hal_crc_ex.c stm32l5xx_hal_cryp.c stm32l5xx_hal_cryp_ex.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_rng.c stm32l5xx_hal_gpio.c stm32l5xx_hal_icache.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c stm32l5xx_hal_usart.c stm32l5xx_hal_usart_ex.c stm32l5xx_hal_lptim.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c stm32l5xx_hal_adc.c stm32l5xx_hal_adc_ex.c stm32l5xx_hal_dac.c stm32l5xx_hal_dac_ex.c stm32l5xx_hal_rtc.c stm32l5xx_hal_rtc_ex.c stm32l5xx_hal_iwdg.c stm32l5xx_hal_wwdg.c stm32l5xx_hal_sd.c stm32l5xx_hal_sd_ex.c stm32l5xx_ll_sdmmc.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c
  group kernel
    ../../../kernel/source/: os_block.c os_clock.c os_event.c os_idle.c os_kernel_lock.c os_kernel_log.c os_mb.c os_mem_firstfit.c os_mem_pool.c os_memory.c os_mq.c os_mutex.c os_sched.c os_sem.c os_spinlock.c os_startup.c os_task.c os_timer.c os_util.c os_version.c os_workqueue.c
  group libc
    ../../../libc/source/armlibc/: access.c chdir.c close.c dirent.c fcntl.c fstat.c fsync.c getcwd.c ioctl.c libc.c lseek.c mem_std.c mkdir.c open.c read.c rename.c rmdir.c stat.c statfs.c stdio.c strdup.c strnlen.c stubs.c time.c unlink.c write.c
    ../../../libc/source/common/: gmtime_r.c
  group sensors
    ../../../drivers/sensors/: sensor.c lsm6dso.c
  group shell
    ../../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
  group stack_trace
    ../../../components/diagnose/stack_trace/: stack_trace.c
