# Keil uVision project project.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32MP157DAAx:Cortex-M4 STMicroelectronics
  pack: Keil.STM32MP1xx_DFP.1.3.0
  cpu: IRAM(0x10020000,0x00020000) IRAM2(0x10040000,0x00020000) IROM(0x10000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: oneos +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OS_TASK_SWITCH_NOTIFY, USE_HAL_DRIVER, NO_ATOMIC_64_SUPPORT, STM32MP157Axx, VIRTIO_SLAVE_ONLY, CORE_CM4, METAL_INTERNAL, METAL_MAX_DEVICE_REGIONS=2
  c include: .;application;..\..\..\arch\arm\armv7m\include;board;..\common\CubeMX_Config\CM4\Core\Inc;..\common\CubeMX_Config\CM4\OPENAMP;..\common\CubeMX_Config\Middlewares\Third_Party\OpenAMP\open-amp\lib\include;..\common\CubeMX_Config\Middlewares\Third_Party\OpenAMP\libmetal\lib\include;..\common\CubeMX_Config\Middlewares\Third_Party\OpenAMP\virtual_driver;board\ports;..\..\..\components\cli\include;..\..\..\common\include;..\..\..\components\dlog\include;..\..\..\drivers;..\..\..\drivers\bus;..\..\..\drivers\console;..\..\..\drivers\dma;..\..\..\drivers\misc;..\..\..\drivers\pin;..\..\..\drivers\serial;..\..\..\drivers\timer;..\..\..\drivers\hal\st\devices;..\..\..\drivers\hal\st\drivers;..\..\..\drivers\hal\st\drivers\config;..\..\..\drivers\hal\st\drivers\drv_flash;..\..\..\drivers\hal\st\STM32MP1xx_HAL\STM32MP1xx_HAL_Driver\Inc;..\..\..\drivers\hal\st\STM32MP1xx_HAL\CMSIS\Device\ST\STM32MP1xx\Include;..\..\..\drivers\hal\st\STM32MP1xx_HAL\CMSIS\Include;..\..\..\kernel\include;..\..\..\libc\include;..\..\..\libc\include\extension;..\..\..\libc\include\armlibc;..\..\..\components\position;..\..\..\components\position\ble_pos\onepos_engine;..\..\..\components\position\ble_pos\onepos_engine\ope_base_calculate;..\..\..\components\position\ble_pos\onepos_engine\ope_base_funtion;..\..\..\components\position\ble_pos\onepos_engine\ope_base_funtion\ope_position_lib;..\..\..\components\position\ble_pos\onepos_engine\ope_base_funtion\ope_position_lib\ope_general_lib;..\..\..\components\position\gnss_pos;..\..\..\components\position\gnss_pos\prot;..\..\..\components\position\gnss_pos\rcvr;..\..\..\components\position\net_pos;..\..\..\components\shell\include;..\..\..\components\diagnose\stack_trace
  asm define: OS_TASK_SWITCH_NOTIFY
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x10020000 size 0x20000
  memory RVCT10: RAM 0x10040000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314,L6330
  group application
    application/: main.c
  group arch
    ../../../arch/arm/armv7m/rvds/: arch_exception_rvds.S arch_task_switch_rvds.S
    ../../../arch/arm/armv7m/: arch_task.c arch_exception.c arch_interrupt.c arch_misc.c arch_atomic.c
  group bsp
    board/: board.c
    ../common/CubeMX_Config/CM4/Core/Src/: bsp.c stm32mp1xx_it_bsp.c stm32mp1xx_hal_msp.c
    ../common/CubeMX_Config/Common/System/: system_stm32mp1xx.c
    board/startup/: startup_stm32mp15xx_arm.s
  group common
    ../../../common/source/: option_parse.c ring_blk_buff.c ring_buff.c
  group dlog
    ../../../components/dlog/source/: dlog.c
    ../../../components/dlog/source/backend/: console_backend.c
  group drivers
    ../../../drivers/: driver.c device.c
    ../../../drivers/bus/: bus.c
    ../../../drivers/console/: console.c
    ../../../drivers/dma/: dma_ram.c soft_dma.c
    ../../../drivers/misc/: push_button.c adc.c
    ../../../drivers/pin/: pin.c
    ../../../drivers/serial/: serial.c
    ../../../drivers/timer/: timer.c clocksource.c clockevent.c hrtimer.c clocksource_cortexm.c
  group hal/devices
    ../../../drivers/hal/st/devices/: stm32_devices.c
  group hal/drivers
    ../../../drivers/hal/st/drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_adc.c drv_common.c
  group hal/lowlevel
    ../../../drivers/hal/st/STM32MP1xx_HAL/STM32MP1xx_HAL_Driver/Src/: stm32mp1xx_hal_rcc.c stm32mp1xx_hal_rcc_ex.c stm32mp1xx_hal_gpio.c stm32mp1xx_hal_hsem.c stm32mp1xx_hal_dma.c stm32mp1xx_hal_dma_ex.c stm32mp1xx_hal_mdma.c stm32mp1xx_hal_pwr.c stm32mp1xx_hal_pwr_ex.c stm32mp1xx_hal_cortex.c stm32mp1xx_hal.c stm32mp1xx_hal_exti.c stm32mp1xx_hal_ipcc.c stm32mp1xx_hal_uart.c stm32mp1xx_hal_usart.c stm32mp1xx_hal_uart_ex.c stm32mp1xx_hal_i2c.c stm32mp1xx_hal_i2c_ex.c stm32mp1xx_hal_spi.c stm32mp1xx_hal_tim.c stm32mp1xx_ll_tim.c stm32mp1xx_hal_tim_ex.c stm32mp1xx_hal_adc.c stm32mp1xx_hal_adc_ex.c stm32mp1xx_hal_dac.c stm32mp1xx_hal_dac_ex.c stm32mp1xx_hal_wwdg.c
  group kernel
    ../../../kernel/source/: os_block.c os_clock.c os_event.c os_idle.c os_kernel_lock.c os_kernel_log.c os_mb.c os_mem_firstfit.c os_mem_pool.c os_memory.c os_mq.c os_mutex.c os_sched.c os_sem.c os_spinlock.c os_startup.c os_task.c os_timer.c os_util.c os_version.c os_workqueue.c
  group libc
    ../../../libc/source/armlibc/: access.c chdir.c close.c dirent.c fcntl.c fstat.c fsync.c getcwd.c ioctl.c libc.c lseek.c mem_std.c mkdir.c open.c read.c rename.c rmdir.c stat.c statfs.c stdio.c strdup.c strnlen.c stubs.c time.c unlink.c write.c
    ../../../libc/source/common/: gmtime_r.c
  group shell
    ../../../components/shell/source/: shell_buildin_cmd.c shell_main.c shell_process.c shell_symbol.c
