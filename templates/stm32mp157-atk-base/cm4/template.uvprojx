# Keil uVision project template.uvprojx, settings and files
target oneos (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32MP157DAAx:Cortex-M4 STMicroelectronics
  pack: Keil.STM32MP1xx_DFP.1.3.0
  cpu: IRAM(0x10020000,0x00020000) IRAM2(0x10040000,0x00020000) IROM(0x10000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: oneos +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_CM4, METAL_MAX_DEVICE_REGIONS=2, USE_HAL_DRIVER, METAL_INTERNAL, OS_USING_ARM_LIBC, STM32MP157Axx, VIRTIO_SLAVE_ONLY, NO_ATOMIC_64_SUPPORT
  c include: .;application;..\..\..\arch\arm\armv7m\include;..\..\..\components\atest\include;board;..\common\CubeMX_Config\CM4\Core\Inc;..\common\CubeMX_Config\CM4\OPENAMP;..\common\CubeMX_Config\Middlewares\Third_Party\OpenAMP\open-amp\lib\include;..\common\CubeMX_Config\Middlewares\Third_Party\OpenAMP\libmetal\lib\include;..\common\CubeMX_Config\Middlewares\Third_Party\OpenAMP\virtual_driver;board\ports;..\..\..\common\include;..\..\..\components\dlog\include;..\..\..\drivers;..\..\..\drivers\bus;..\..\..\drivers\console;..\..\..\drivers\dma;..\..\..\drivers\i2c;..\..\..\drivers\misc;..\..\..\drivers\pin;..\..\..\drivers\rtc;..\..\..\drivers\serial;..\..\..\drivers\spi;..\..\..\drivers\timer;..\..\..\drivers\watchdog;..\..\..\components\fs\include;..\..\..\components\fs\include\devfs;..\..\..\drivers\hal\st\devices;..\..\..\drivers\hal\st\drivers;..\..\..\drivers\hal\st\drivers\drv_config;..\..\..\drivers\hal\st\drivers\config;..\..\..\drivers\hal\st\drivers\drv_flash;..\..\..\drivers\hal\st\STM32MP1xx_HAL\STM32MP1xx_HAL_Driver\Inc;..\..\..\drivers\hal\st\STM32MP1xx_HAL\CMSIS\Device\ST\STM32MP1xx\Include;..\..\..\drivers\hal\st\STM32MP1xx_HAL\CMSIS\Include;..\..\..\kernel\include;..\..\..\libc\include;..\..\..\libc\include\armlibc;..\..\..\components\diagnose\resource_moniter;..\..\..\components\shell\include;..\..\..\components\diagnose\stack_trace
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x10020000 size 0x20000
  memory RVCT10: RAM 0x10040000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress L6314,L6330
