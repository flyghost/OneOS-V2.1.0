# Keil uVision project CubeMX_Config.uvprojx, settings and files
target CubeMX_Config (ARM-ADS)
  device: STM32MP157DAAx:Cortex-M4 STMicroelectronics
  cpu: IRAM(0x10020000-0x1003FFFF) IRAM2(0x10040000-0x1005FFFF) IROM(0x10000000-0x1001FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: CubeMX_Config +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  c define: CORE_CM4,USE_HAL_DRIVER,STM32MP157Dxx
  c include: ../CM4/Core/Inc;        ../Drivers/STM32MP1xx_HAL_Driver/Inc;        ../Drivers/STM32MP1xx_HAL_Driver/Inc/Legacy;        ../Drivers/CMSIS/Device/ST/STM32MP1xx/Include;        ../Drivers/CMSIS/Include
  scatter file: stm32mp15xx_m4.sct
  group Application/MDK-ARM
    ./: startup_stm32mp15xx.s
  group Application/User/CM4/Core
    ../CM4/Core/Src/: main.c stm32mp1xx_it.c stm32mp1xx_hal_msp.c
  group Drivers/STM32MP1xx_HAL_Driver
    ../Drivers/STM32MP1xx_HAL_Driver/Src/: stm32mp1xx_ll_adc.c stm32mp1xx_hal_adc.c stm32mp1xx_hal_adc_ex.c stm32mp1xx_hal_rcc.c stm32mp1xx_hal_rcc_ex.c stm32mp1xx_hal_gpio.c stm32mp1xx_hal_hsem.c stm32mp1xx_hal_dma.c stm32mp1xx_hal_dma_ex.c stm32mp1xx_hal_mdma.c stm32mp1xx_hal_pwr.c stm32mp1xx_hal_pwr_ex.c stm32mp1xx_hal_cortex.c stm32mp1xx_hal.c stm32mp1xx_hal_exti.c stm32mp1xx_hal_dac.c stm32mp1xx_hal_dac_ex.c stm32mp1xx_hal_i2c.c stm32mp1xx_hal_i2c_ex.c stm32mp1xx_hal_ipcc.c stm32mp1xx_hal_spi.c stm32mp1xx_hal_spi_ex.c stm32mp1xx_hal_tim.c stm32mp1xx_hal_tim_ex.c stm32mp1xx_hal_uart.c stm32mp1xx_hal_uart_ex.c stm32mp1xx_hal_wwdg.c
  group Drivers/CMSIS
    ../Common/System/: system_stm32mp1xx.c
software components: CMSIS:CORE 4.3.0
